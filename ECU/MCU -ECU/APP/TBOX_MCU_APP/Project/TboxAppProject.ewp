# IAR project TboxAppProject.ewp, settings and files
configuration APP (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40_41xxx
  ICCARM.CCIncludePath2: ..\Common\Library\CORE; ..\Common\Library\FWLIB\inc; ..\Common\System; ..\Common\Hardware\Driver\Include; ..\Common\Hardware\Api\Include; ..\Common\FreeRtos\portable\IAR\ARM_CM4F; ..\Common\FreeRtos\include; ..\BootLoader\Main; ..\App\Main; ..\App\Tp&UDS\CanTp\Inc; ..\App\Tp&UDS\Common\Inc; ..\App\Tp&UDS\Routing\Inc; ..\App\Tp&UDS\UDS\Inc; ..\App\Mpu&McuCom\gen\Inc; ..\App\Mpu&McuCom\src\core\Inc; ..\App\Mpu&McuCom\src\hal\Inc; ..\App\Mpu&McuCom\src\sys\include; ..\App\Mpu&McuCom\src\util\Inc; ..\App\Mpu&McuCom\usr\Inc; ..\App\Mpu_McuCom\include; ..\App\OTA_Flash\include; ..\App\Usart\inc; ..\App\InforCol\Inc; ..\App\EepManag\Inc; ..\App\HMAC; ..\App\MpuPwrCtrl\Inc; ..\App\Tp&UDS\Routing\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Common\Library\CORE; ..\Common\FreeRtos\portable\IAR\ARM_CM4F; ..\Common\FreeRtos\include
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.hex
  ILINK.IlinkOutputFile: McuProject.out
  ILINK.IlinkIcfFile: stm32f407xx_app_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP/EepManag
    ../App/EepManag/Src/: EepManage.c
  group APP/HMAC
    ../App/HMAC/: sm3.c
  group APP/Main
    ../App/Main/: main.c
  group APP/MpuPowerCtrl
    ../App/MpuPwrCtrl/Src/: MpuPowerCtrl.c
  group APP/Tp&UDS/CanTp
    ../App/Tp&UDS/CanTp/Src/: ISO15765_2.c
  group APP/Tp&UDS/Common
    ../App/Tp&UDS/Common/Src/: CAN.c CanQueue.c Timer.c
  group APP/Tp&UDS/Routing
    ../App/Tp&UDS/Routing/Src/: Routing.c
  group APP/Tp&UDS/UDS
    ../App/Tp&UDS/UDS/Src/: ISO14229_1.c
  group APP/Usart_Com
    ../App/Usart/src/: escape.c Trans.c Uart.c
  group FreeRtos/Kernel
    ../Common/FreeRtos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRtos/Portable
    ../Common/FreeRtos/portable/MemMang/: heap_4.c
    ../Common/FreeRtos/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Hardware/Api
    ../Common/Hardware/Api/: ComUsart.c Eeprom.c Logging.c Spi_Flash.c St_Flash.c
  group Hardware/Driver
    ../Common/Hardware/Driver/: CAN1_Driver.c CAN2_Driver.c ComUsart_Driver.c Crc_Driver.c DbgUsart_Driver.c Flash_Driver.c IIC_Driver.c Key_Driver.c Led_Driver.c Rng_Driver.c RtcTime_Driver.c Spi_Driver.c Timer_Driver.c Wdg_Driver.c
  group McuCore
    ../Common/System/: delay.c stm32f4xx_it.c system.c
    ../Common/Library/CORE/: startup_stm32f407xx.s system_stm32f4xx.c
  group McuLib
    ../Common/Library/FWLIB/src/: misc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
