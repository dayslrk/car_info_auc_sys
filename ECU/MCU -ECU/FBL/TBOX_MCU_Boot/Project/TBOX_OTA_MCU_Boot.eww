<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\TBOX_OTA_MCU_Boot.ewp</path>
    </project>
    <batchBuild />
</workspace>
